# Keil uVision project prj3633.uvproj, settings and files
target Target1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: bk3633_app
  AfterMake: fromelf --bin --output .\output\app\bk3633_app.bin .\obj\bk3633_app.axf
  AfterMake: .\output\translate.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CPU_BK3633
  c misc: --gnu
  c include: ..\..\src\ip\ble\ll\api;..\..\src\ip\ble\ll\import\reg;..\..\src\ip\ble\ll\src;..\..\src\ip\bt\api;..\..\src\ip\bt\import\reg;..\..\src\ip\bt\src;..\..\src\ip\em\api;..\..\src\ip\hci\api;..\..\src\ip\sch\api;..\..\src\ip\sch\import;..\..\src\modules\aes\api;..\..\src\modules\common\api;..\..\src\modules\dbg\api;..\..\src\modules\ecc_p256\api;..\..\src\modules\h4tl\api;..\..\src\modules\ke\api;..\..\src\plf\nvds\api;..\..\src\driver\rf;..\..\src\plf\rwip\api;..\..\src\plf\rwip\import\reg;..\..\src\plf\refip\import\reg;..\..\src\plf\refip\src\arch;..\..\src\plf\refip\src\arch\boot\rvds;..\..\src\plf\refip\src\arch\compiler\rvds;..\..\src\plf\refip\src\arch\ll\rvds;..\..\src\driver\flash;..\..\src\driver\led;..\..\src\driver\reg;..\..\src\driver\syscntl;..\..\src\driver\timer;..\..\src\driver\uart;..\..\src\driver\uart2;..\..\Src\header;..\..\Src\header\header_file;..\..\Src\plf\refip\src\driver;..\..\Src\ip\ble\hl\api;..\..\Src\ip\ble\hl\inc;..\..\Src\ip\ble\hl\src\gap\gapc;..\..\Src\ip\ble\hl\src\gap\gapm;..\..\Src\ip\ble\hl\src\gatt;..\..\Src\ip\ble\hl\src\gatt\attc;..\..\Src\ip\ble\hl\src\gatt\attm;..\..\Src\ip\ble\hl\src\gatt\atts;..\..\Src\ip\ble\hl\src\gatt\gattc;..\..\Src\ip\ble\hl\src\gatt\gattm;..\..\Src\ip\ble\hl\src\l2c\l2cc;..\..\Src\ip\ble\hl\src\l2c\l2cm;..\..\Src\app\api;..\..\Src\profiles\dis\diss\api;..\..\Src\profiles\FEE0\api;..\..\Src\profiles\bas\bass\api;..\..\Src\profiles\FCC0_128\api;..\..\Src\driver\gpio;..\..\Src\driver\spi;..\..\Src\driver\icu;..\..\Src\driver\wdt;..\..\Src\driver\adc;..\..\Src\profiles\ancs\ancsc\api;..\..\Src\profiles\oad\api;..\..\Src\profiles\ancs\ancsc;.\config;.\app\api;..\..\src\driver\aon_rtc;..\..\src\plf\prf;..\..\Src\driver\intc;..\..\src\driver\dma;..\..\src\driver\i2c;..\..\src\device\lcd;..\..\Src\profiles\sdp\api;..\..\src\driver\usb;..\..\src\driver\usb\include;..\..\src\driver\usb\include\class;..\..\src\driver\usb\src\cd;..\..\src\driver\usb\src\drivers\comm;..\..\src\driver\usb\src\drivers\msd;..\..\src\driver\usb\src\examples;..\..\src\driver\usb\src\functions\trans_fn;..\..\src\driver\usb\src\systems\none;..\..\src\driver\usb\src\systems\none\afs;..\..\src\driver\usb\src\test;..\..\src\driver\usb\src\test\msd;..\..\src\driver\pwm;..\..\src\driver\timer0;..\..\src\HBLIB;..\..\src\FitShow;..\..\src\profiles\FFF0\src;..\..\src\profiles\FFF0\api;..\..\src\profiles\FTMS\src;..\..\src\profiles\FTMS\api;..\..\src\profiles\FTMS;..\..\src\profiles\FFF0;..\..\src\pulse_mode
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x400000 size 0x10000
  scatter file: ..\..\src\system\all_roles_app_link_1.txt
  link misc: --entry sys_Reset
  group system
    ../../src/system/: all_roles_stack_symbol.txt boot_handlers.s boot_vectors.s
    ./app/src/: main.c
  group app
    ./app/src/: app.c app_batt.c app_dis.c app_fcc0.c app_fee0.c app_oads.c app_sec.c app_task.c app_adv.c app_scan.c app_init.c app_mesh_adv.c mesh_sec.c
    ../../src/profiles/FFF0/src/: app_fff0.c
    ../../src/profiles/FTMS/src/: app_ftms.c
  group plf
    ../../Src/plf/rwip/src//: rwbt.c
    ../../Src/plf/rwip/src/: rwble.c rwip.c
    ../../Src/plf/nvds/src/: nvds.c
    ../../src/plf/prf/: prf_utils.c prf.c
  group driver
    ../../Src/driver/flash/: flash.c
    ../../Src/driver/rf/: rf_xvr.c
    ../../Src/driver/gpio/: gpio.c
    ../../Src/driver/spi/: spi.c
    ../../Src/driver/icu/: icu.c
    ../../Src/driver/wdt/: wdt.c
    ../../Src/driver/adc/: adc.c
    ../../Src/driver/uart2/: uart2.c
    ../../src/driver/uart/: uart.c
    ../../src/driver/aon_rtc/: aon_rtc.c
    ../../src/driver/intc/: intc.c
    ../../src/driver/i2c/: i2c.c
    ../../src/driver/dma/: dma.c
    ../../src/driver/pwm/: pwm.c
    ../../src/driver/timer0/: timer0.c
  group profiles
    ../../Src/profiles/dis/diss/src/: diss.c diss_task.c
    ../../Src/profiles/FEE0/src/: fee0s.c fee0s_task.c
    ../../Src/profiles/bas/bass/src/: bass.c bass_task.c
    ../../Src/profiles/FCC0_128/src/: fcc0s.c fcc0s_task.c
    ../../Src/profiles/oad/src/: oads.c oads_task.c
    ../../src/profiles/sdp/src/: sdp_service_task.c sdp_service.c
    ../../src/profiles/FTMS/src/: ftms.c ftms_task.c
    ../../src/profiles/FFF0/src/: fff0s.c fff0s_task.c
  group config
    ./config/: rwapp_config.h user_config.h rwip_config.h rwprf_config.h
  group list_hb
    ../../src/HBLIB/: list_hb.c Match_hb.c
  group FitShow
    ../../src/FitShow/: DataSerialization.c Device.c FitShow.c SystemConfig.c
  group pulse_mode
    ../../src/pulse_mode/: pulse_frame.c timer_task_frame.c
